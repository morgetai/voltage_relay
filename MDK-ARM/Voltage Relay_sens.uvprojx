# Keil uVision project Voltage Relay_sens.uvprojx, settings and files
target Voltage Relay_sens (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F071CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Voltage Relay_sens +hex
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F071xB,STM32F0XX_MD,ARM_MATH_CM0
  c misc: --cpp11 --cpu=Cortex-M0
  c include: ../Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;          ../Drivers/CMSIS/Include;          ..\Drivers\STMTouch_Driver\inc;          ..\Drivers\STMTouch_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_dma.c stm32f0xx_hal_tsc.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_adc.c stm32f0xx_hal_rcc.c stm32f0xx_hal.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: help.cpp Screen.cpp tsl_user.c keyboard.cpp stm32f0xx_hal_msp.c stm32f0xx_it.c eeprom.c eeprom_user.cpp voltage_acq.cpp voltage_relay.cpp main_state_machine.cpp alarms_events.cpp observer.cpp main.c menu.cpp
    ../Drivers/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_fir_f32.c arm_fir_init_f32.c
  group Application/MDK-ARM
    ./: startup_stm32f071xb.s
  group Touch_Driver
    ../Drivers/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32f0xx.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32f0xx.c tsl_touchkey.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.3.3
